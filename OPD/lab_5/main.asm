ORG 0x29D
ADR:	WORD $RES
START:	CLA

SYM1:	IN 5
	AND #0x40
	BEQ SYM1
	IN 4
	CMP #0x0A
	BEQ END1
	SWAB
	ST (ADR)
		
SYM2:	IN 5
	AND #0x40
	BEQ SYM2
	IN 4
	CMP #0x0A
	BEQ END1
	OR (ADR)
	ST (ADR)+
	JUMP SYM1

END1:	OR (ADR)
	ST (ADR)
	HLT
		
ORG 0x63C
RES: 	WORD 0



